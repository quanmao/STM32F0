# Keil uVision project project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c misc: --cpp
  c include: .\inc;.\lib\API\inc;.\lib\CMSIS\Device\ST\STM32F0xx\Include;.\lib\STM32F0\inc;.\lib\MISC\inc;.\lib\FATFS\option;.\lib\FATFS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group System
    ./src/: stm32f0xx_it.c
    ./inc/: stm32f0xx_it.h stm32f0xx_conf.h
  group CMSIS
    ./lib/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ./lib/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
    ./lib/CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h
  group STM32F0
    ./lib/STM32F0/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group FATFS
    ./lib/FATFS/: diskio.c ff.c sdcard.c
  group API
    ./lib/API/src/: Common.c Delay.c Digital.cpp Analog.cpp Timer.cpp Systick.c I2C.cpp Serial.cpp SPI.cpp Touch.cpp
  group User
    ./src/: main.c
