# Keil uVision project template.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --cpp
  c include: .\inc;.\lib\API\inc;.\lib\CMSIS\Device\ST\STM32F0xx\Include;.\lib\MISC\inc;.\lib\STM32F0\inc;.\lib\FreeRTOS\Source\include;.\lib\FreeRTOS\Demo\CORTEX_M0_STM32F0518_IAR;.\lib\FreeRTOS\Source\portable\RVDS\ARM_CM0;.\lib\CMSIS\Include
  asm include: .\lib\FREERTOS\Source\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group System
    ./lib/CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h
    ./inc/: stm32f0xx_it.h stm32f0xx_conf.h
    ./src/: stm32f0xx_it.c
  group CMSIS
    ./lib/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
    ./lib/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group STM32F0
    ./lib/STM32F0/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group API
    ./lib/API/src/: Common.c Systick.c Delay.c Analog.cpp Digital.cpp Timer.cpp Serial.cpp I2C.cpp SPI.cpp Touch.cpp Watchdog.cpp Memory.cpp Power.cpp RTC.cpp
  group User
    ./src/: main.c
    ./lib/MISC/src/: SevenSeg.cpp DS3231.cpp Button.cpp Encoder.cpp MCP9803.cpp HCSR04.cpp FONA.cpp
